# Keil uVision project Lab14.uvproj, settings and files
target Lab14 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab14
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s MeasurementOfDistance.c ADC.c VirtualNokia5110.c
  group Object code
    ./: texas.o
